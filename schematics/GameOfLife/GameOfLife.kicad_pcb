# Repository somas95/E-T-A

## KiCad design schematics/GameOfLife/GameOfLife.kicad_pcb

Parts:
A1: Arduino_Nano_v3.x; Arduino_Nano
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72: A9050; R_LDR_5.0x4.1mm_P3mm_Vertical
U1: 74HC595; DIP-16_W7.62mm
U2: CD74HC4067M; SOIC-24W_7.5x15.4mm_P1.27mm

Connections:
unnamed 4: A1.5 (D2); also elsewhere on the board
unnamed 5: A1.6 (D3); also elsewhere on the board
unnamed 6: A1.7 (D4); also elsewhere on the board
unnamed: A1.11 (D8), U1.12 (RCLK)
unnamed: A1.14 (D11), U1.14 (SER)
unnamed: A1.15 (D12), U1.11 (SRCLK)
unnamed 18: A1.19 (A0); also elsewhere on the board
unnamed 26: A1.27 (+5V), U1.10 (~SRCLR), U1.16 (VCC); also elsewhere on the board
unnamed 28: A1.29 (GND), R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, U1.8 (GND), U1.13 (~OE); also elsewhere on the board
unnamed 30: D1.1 (K), D9.1 (K), D17.1 (K), D25.1 (K), D33.1 (K), D41.1 (K), D49.1 (K), D57.1 (K), R1.2; also elsewhere on the board
unnamed: D1.2 (A), R9.2
unnamed: D2.2 (A), R10.2
unnamed: D3.2 (A), R11.2
unnamed: D4.2 (A), R12.2
unnamed: D5.2 (A), R13.2
unnamed: D6.2 (A), R14.2
unnamed: D7.2 (A), R15.2
unnamed: D8.2 (A), R16.2
unnamed: D9.2 (A), R17.2
unnamed 40: D2.1 (K), D10.1 (K), D18.1 (K), D26.1 (K), D34.1 (K), D42.1 (K), D50.1 (K), D58.1 (K), R2.2; also elsewhere on the board
unnamed: D10.2 (A), R18.2
unnamed 42: D3.1 (K), D11.1 (K), D19.1 (K), D27.1 (K), D35.1 (K), D43.1 (K), D51.1 (K), D59.1 (K), R3.2; also elsewhere on the board
unnamed: D11.2 (A), R19.2
unnamed 44: D4.1 (K), D12.1 (K), D20.1 (K), D28.1 (K), D36.1 (K), D44.1 (K), D52.1 (K), D60.1 (K), R4.2; also elsewhere on the board
unnamed: D12.2 (A), R20.2
unnamed 46: D5.1 (K), D13.1 (K), D21.1 (K), D29.1 (K), D37.1 (K), D45.1 (K), D53.1 (K), D61.1 (K), R5.2; also elsewhere on the board
unnamed: D13.2 (A), R21.2
unnamed 48: D6.1 (K), D14.1 (K), D22.1 (K), D30.1 (K), D38.1 (K), D46.1 (K), D54.1 (K), D62.1 (K), R6.2; also elsewhere on the board
unnamed: D14.2 (A), R22.2
unnamed 50: D7.1 (K), D15.1 (K), D23.1 (K), D31.1 (K), D39.1 (K), D47.1 (K), D55.1 (K), D63.1 (K), R7.2; also elsewhere on the board
unnamed: D15.2 (A), R23.2
unnamed 52: D8.1 (K), D16.1 (K), D24.1 (K), D32.1 (K), D40.1 (K), D48.1 (K), D56.1 (K), D64.1 (K), R8.2; also elsewhere on the board
unnamed: D16.2 (A), R24.2
unnamed: D17.2 (A), R25.2
unnamed: D18.2 (A), R26.2
unnamed: D19.2 (A), R27.2
unnamed: D20.2 (A), R28.2
unnamed: D21.2 (A), R29.2
unnamed: D22.2 (A), R30.2
unnamed: D23.2 (A), R31.2
unnamed: D24.2 (A), R32.2
unnamed: D25.2 (A), R33.2
unnamed: D26.2 (A), R34.2
unnamed: D27.2 (A), R35.2
unnamed: D28.2 (A), R36.2
unnamed: D29.2 (A), R37.2
unnamed: D30.2 (A), R38.2
unnamed: D31.2 (A), R39.2
unnamed: D32.2 (A), R40.2
unnamed: D33.2 (A), R41.2
unnamed: D34.2 (A), R42.2
unnamed: D35.2 (A), R43.2
unnamed: D36.2 (A), R44.2
unnamed: D37.2 (A), R45.2
unnamed: D38.2 (A), R46.2
unnamed: D39.2 (A), R47.2
unnamed: D40.2 (A), R48.2
unnamed: D41.2 (A), R49.2
unnamed: D42.2 (A), R50.2
unnamed: D43.2 (A), R51.2
unnamed: D44.2 (A), R52.2
unnamed: D45.2 (A), R53.2
unnamed: D46.2 (A), R54.2
unnamed: D47.2 (A), R55.2
unnamed: D48.2 (A), R56.2
unnamed: D49.2 (A), R57.2
unnamed: D50.2 (A), R58.2
unnamed: D51.2 (A), R59.2
unnamed: D52.2 (A), R60.2
unnamed: D53.2 (A), R61.2
unnamed: D54.2 (A), R62.2
unnamed: D55.2 (A), R63.2
unnamed: D56.2 (A), R64.2
unnamed: D57.2 (A), R65.2
unnamed: D58.2 (A), R66.2
unnamed: D59.2 (A), R67.2
unnamed: D60.2 (A), R68.2
unnamed: D61.2 (A), R69.2
unnamed: D62.2 (A), R70.2
unnamed: D63.2 (A), R71.2
unnamed: D64.2 (A), R72.2
unnamed: R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, U1.7 (QH)
unnamed: R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, U1.6 (QG)
unnamed: R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, U1.5 (QF)
unnamed: R33.1, R34.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1, U1.4 (QE)
unnamed: R41.1, R42.1, R43.1, R44.1, R45.1, R46.1, R47.1, R48.1, U1.3 (QD)
unnamed: R49.1, R50.1, R51.1, R52.1, R53.1, R54.1, R55.1, R56.1, U1.2 (QC)
unnamed: R57.1, R58.1, R59.1, R60.1, R61.1, R62.1, R63.1, R64.1, U1.1 (QB)
unnamed: R65.1, R66.1, R67.1, R68.1, R69.1, R70.1, R71.1, R72.1, U1.15 (QA)

Notes on the sheet:
https://www.arduino.cc/en/Tutorial/ShftOut12 https://www.arduino.cc/en/Tutorial/ShftOut13

Board: 2 copper layers, 139 parts (0 on the bottom side), 89 nets.

Other parts of the board:
TB1: BOB-09056; XDCR_BOB-09056

Their connections:
unnamed 4: TB1.4; also elsewhere on the board
unnamed 5: TB1.5; also elsewhere on the board
unnamed 6: TB1.6; also elsewhere on the board
unnamed 18: TB1.8; also elsewhere on the board
unnamed 26: TB1.2; also elsewhere on the board
unnamed 28: TB1.1, TB1.3, TB1.7; also elsewhere on the board
unnamed 30: TB1.9; also elsewhere on the board
unnamed 40: TB1.10; also elsewhere on the board
unnamed 42: TB1.11; also elsewhere on the board
unnamed 44: TB1.12; also elsewhere on the board
unnamed 46: TB1.13; also elsewhere on the board
unnamed 48: TB1.14; also elsewhere on the board
unnamed 50: TB1.15; also elsewhere on the board
unnamed 52: TB1.16; also elsewhere on the board

## Commit log

2020-06-20 Update schematics
2020-06-21 Update pcb
